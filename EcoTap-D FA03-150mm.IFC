Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: 檯面式150mm_一英寸組合件_SV270_202608.IFC
Time: 2026-08-27T03:57:41
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 101-32N (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 202307_2464#26_一英寸感應器線組+公母頭
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 270-01
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 270-02
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 270-03 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 270-04
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 302-40 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: A0135-0026_EcoTap_一英寸感應器膠殼
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: A0135-0029_快接頭固定夾
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: A0135-0036_EcoTap_一英寸出水件
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: A0135-0037_EcoTap_出水口固定件
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: C0335-0032_EcoTap_定位墊片
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: D0235-0032_EcoTap_FA_白鐵編織軟管_800mm
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: EcoTap出風龍頭墊片
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: EcoTap墊片
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: SENSOR MALE
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: T0635-0001_AutoTap電源穩壓器
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 一英寸_檯面式不銹鋼管本體_150mm_20240723
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 一英寸華司
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 一英寸飾蓋
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 不銹鋼龍頭管座_防轉片用_20240723
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 內六角無頭螺柱_3×4mm_SUS
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 內六角無頭螺柱_5×8mm_SUS (2)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 圓角2
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 填料-伸長3
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 填料-伸長7
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 旋轉3
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 磁閥導線202505
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 進風管固定螺帽_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 除料-伸長3
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 除料-旋轉1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 除料-旋轉2[2]
In: Default Storey
PredefinedType: ELEMENT
